# Keil uVision project 0710.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: 0710 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: delay.c delay.h DS18B20.c DS18B20.h ds1302.c ds1302.h main.c Serial.c Serial.h Timer.c Timer.h
